# Keil uVision project 05_Motor_Ctrl_CLI.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 05_Motor_Ctrl_CLI +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c uart.c conf.h constants.h main.h port.h uart.h
